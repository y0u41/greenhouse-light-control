# Keil uVision project greenhouse.uvprojx, settings and files
target Greenhouse (6240000::V6.24::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: greenhouse +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,DEBUG_UART=1
  c misc: -Wno-unused-function -Wno-unused-parameter -Wno-char-subscripts -Wno-missing-braces -Wno-missing-field-initializers -Wno-invalid-source-encoding
  c include: ..\..\Core\Inc;..\..\Middlewares;..\..\Middlewares\cJSON;..\..\Drivers;..\..\Drivers\BSP\LCD;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f103xe.s
  group Core
    ../../Core/Src/: main.c adc_light.c control.c eeprom.c esp8266.c lcd_show.c debug_uart.c retarget.c protocol.c stm32f1xx_it.c system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
  group Drivers/BSP
    ../../Drivers/BSP/LCD/: lcd.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c
  group Middlewares
    ../../Middlewares/cJSON/: cJSON.c
software components: CMSIS:CORE 4.3.0
